# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rtthread-w60x
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: .\makeimg.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --c99 --gnu
  memory RVCT4: ROM 0x8010100 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
